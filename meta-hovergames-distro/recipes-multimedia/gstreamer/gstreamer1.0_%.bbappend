RDEPENDS_${PN}_remove = " libglib-2.0-0"

RDEPENDS_${PN} = " "

RRECOMMENDS_${PN} = " "