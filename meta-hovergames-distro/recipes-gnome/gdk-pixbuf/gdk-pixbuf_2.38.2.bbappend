#
# This class will generate the proper postinst/postrm scriptlets for pixbuf
# packages.
#


pixbufcache_common() {
}

python populate_packages_append() {
}

gdkpixbuf_complete() {
}


pixbufcache_sstate_postinst() {
}
