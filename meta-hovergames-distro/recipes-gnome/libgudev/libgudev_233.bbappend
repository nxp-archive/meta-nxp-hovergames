RCONFLICTS_${PN}_remove = "systemd (<= 220)"

RCONFLICTS_${PN} = ""