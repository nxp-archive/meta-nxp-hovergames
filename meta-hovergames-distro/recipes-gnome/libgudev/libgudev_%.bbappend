RCONFLICTS_${PN}_remove = "systemd (<= 220)"

RCONFLICTS_libgudev_remove = "systemd (<= 220)"

