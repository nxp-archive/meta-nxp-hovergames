
gtk_icon_cache_postinst() {
}

gtk_icon_cache_postrm() {
}

python populate_packages_append () {
}

