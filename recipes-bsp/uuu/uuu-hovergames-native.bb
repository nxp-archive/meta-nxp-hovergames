require uuu-script-native.inc

IMAGES = " \
    imx-image-hovergames-melodic \
    imx-image-hovergames-minimal-melodic \
"
SD_NUM = "1"
EMMC_NUM = "2"
