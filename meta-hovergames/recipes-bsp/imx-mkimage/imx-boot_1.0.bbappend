FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

SRC_URI += "file://0001-Add-i.MX-8M-Mini-NavQ-support.patch"
